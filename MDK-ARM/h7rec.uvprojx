# Keil uVision project h7rec.uvprojx, settings and files
target h7rec (6220000::V6.22::ARMCLANG)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h7rec +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,LV_CONF_INCLUDE_SIMPLE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../App/FileTransfer;../App/Storage;../App/Runtime;../App/Camera;../App/Gui;../App/Gui/LvglPort;../External/lvgl-8.4.0;../External/lvgl-8.4.0/src;../External/keil_ac6_rlottie/install/include;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../BSP/ST7735;../BSP/ov7725m12;../External/CherryUSB-1.6.1/core;../External/CherryUSB-1.6.1/osal;../External/CherryUSB-1.6.1/port/dwc2;../External/CherryUSB-1.6.1/class/cdc;../External/CherryUSB-1.6.1/class/msc;../External/CherryUSB-1.6.1/common;../BSP/CherryUSB_port;../External/SEGGER_RTT_V798a/RTT;../External/SEGGER_RTT_V798a/Config;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\h7rec.sct
  link libs: rlottie.lib
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dcmi.c dma.c fmc.c i2c.c memorymap.c rtc.c sdmmc.c spi.c tim.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/App/FileTransfer
    ../App/FileTransfer/: file_rx.c
  group Application/User/App/Storage
    ../App/Storage/: sd_manager.c
  group Application/User/App/Runtime
    ../App/Runtime/: app_runtime.c
    ../External/keil_ac6_rlottie/keil/: keil_ac6_retarget.c
  group Application/User/App/Camera
    ../App/Camera/: app_camera.c
  group Application/User/App/Gui
    ../App/Gui/: app_gui.c
    ../External/keil_ac6_rlottie/install/lib/: rlottie.lib
  group Application/User/App/Gui/LvglPort
    ../App/Gui/LvglPort/: lv_port_disp.c lv_port_indev.c lv_port_fs.c
  group External/LVGL/core
    ../External/lvgl-8.4.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group External/LVGL/hal
    ../External/lvgl-8.4.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group External/LVGL/misc
    ../External/lvgl-8.4.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group External/LVGL/draw
    ../External/lvgl-8.4.0/src/draw/arm2d/: lv_gpu_arm2d.c
    ../External/lvgl-8.4.0/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../External/lvgl-8.4.0/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../External/lvgl-8.4.0/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../External/lvgl-8.4.0/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../External/lvgl-8.4.0/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../External/lvgl-8.4.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../External/lvgl-8.4.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../External/lvgl-8.4.0/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
  group External/LVGL/font
    ../External/lvgl-8.4.0/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
  group External/LVGL/widgets
    ../External/lvgl-8.4.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group External/LVGL/extra
    ../External/lvgl-8.4.0/src/extra/layouts/flex/: lv_flex.c
    ../External/lvgl-8.4.0/src/extra/layouts/grid/: lv_grid.c
    ../External/lvgl-8.4.0/src/extra/libs/bmp/: lv_bmp.c
    ../External/lvgl-8.4.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../External/lvgl-8.4.0/src/extra/libs/freetype/: lv_freetype.c
    ../External/lvgl-8.4.0/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../External/lvgl-8.4.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../External/lvgl-8.4.0/src/extra/libs/png/: lodepng.c lv_png.c
    ../External/lvgl-8.4.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../External/lvgl-8.4.0/src/extra/libs/rlottie/: lv_rlottie.c
    ../External/lvgl-8.4.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../External/lvgl-8.4.0/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../External/lvgl-8.4.0/src/extra/: lv_extra.c
    ../External/lvgl-8.4.0/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../External/lvgl-8.4.0/src/extra/others/gridnav/: lv_gridnav.c
    ../External/lvgl-8.4.0/src/extra/others/ime/: lv_ime_pinyin.c
    ../External/lvgl-8.4.0/src/extra/others/imgfont/: lv_imgfont.c
    ../External/lvgl-8.4.0/src/extra/others/monkey/: lv_monkey.c
    ../External/lvgl-8.4.0/src/extra/others/msg/: lv_msg.c
    ../External/lvgl-8.4.0/src/extra/others/snapshot/: lv_snapshot.c
    ../External/lvgl-8.4.0/src/extra/themes/basic/: lv_theme_basic.c
    ../External/lvgl-8.4.0/src/extra/themes/default/: lv_theme_default.c
    ../External/lvgl-8.4.0/src/extra/themes/mono/: lv_theme_mono.c
    ../External/lvgl-8.4.0/src/extra/widgets/animimg/: lv_animimg.c
    ../External/lvgl-8.4.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../External/lvgl-8.4.0/src/extra/widgets/chart/: lv_chart.c
    ../External/lvgl-8.4.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../External/lvgl-8.4.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../External/lvgl-8.4.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../External/lvgl-8.4.0/src/extra/widgets/led/: lv_led.c
    ../External/lvgl-8.4.0/src/extra/widgets/list/: lv_list.c
    ../External/lvgl-8.4.0/src/extra/widgets/menu/: lv_menu.c
    ../External/lvgl-8.4.0/src/extra/widgets/meter/: lv_meter.c
    ../External/lvgl-8.4.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../External/lvgl-8.4.0/src/extra/widgets/span/: lv_span.c
    ../External/lvgl-8.4.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../External/lvgl-8.4.0/src/extra/widgets/spinner/: lv_spinner.c
    ../External/lvgl-8.4.0/src/extra/widgets/tabview/: lv_tabview.c
    ../External/lvgl-8.4.0/src/extra/widgets/tileview/: lv_tileview.c
    ../External/lvgl-8.4.0/src/extra/widgets/win/: lv_win.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group ST7735
    ../BSP/ST7735/: lcd.c logo_128_160.c logo_160_80.c st7735.c st7735_reg.c
  group OV7725M12
    ../BSP/ov7725m12/: ov7725m12.c
  group cherryusb
    ../External/CherryUSB-1.6.1/core/: usbd_core.c
    ../External/CherryUSB-1.6.1/class/cdc/: usbd_cdc_acm.c
    ../External/CherryUSB-1.6.1/class/msc/: usbd_msc.c
    ../External/CherryUSB-1.6.1/port/dwc2/: usb_dc_dwc2.c
    ../External/CherryUSB-1.6.1/osal/: usb_osal_freertos.c
    ../BSP/CherryUSB_port/: usb_dwc2_port.c cherryusb_app.c
  group SEGGER_RTT
    ../External/SEGGER_RTT_V798a/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
software components: CMSIS:CORE 6.1.0
